// SPDX-License-Identifier: GPL-2.0-or-later

#include "rtl8380_zyxel_gs1900.dtsi"
#include "rtl8380_zyxel_gs1900_gpio.dtsi"

/ {
	compatible = "zyxel,gs1900-24e-a1", "realtek,rtl838x-soc";
	model = "Zyxel GS1900-24E A1";
};

&mdio_bus0 {
	EXTERNAL_PHY(0)
	EXTERNAL_PHY(1)
	EXTERNAL_PHY(2)
	EXTERNAL_PHY(3)
	EXTERNAL_PHY(4)
	EXTERNAL_PHY(5)
	EXTERNAL_PHY(6)
	EXTERNAL_PHY(7)

	EXTERNAL_PHY(16)
	EXTERNAL_PHY(17)
	EXTERNAL_PHY(18)
	EXTERNAL_PHY(19)
	EXTERNAL_PHY(20)
	EXTERNAL_PHY(21)
	EXTERNAL_PHY(22)
	EXTERNAL_PHY(23)
};

&switch0 {
	ports {
		SWITCH_PORT_SDS(1, 1, 0, qsgmii)
		SWITCH_PORT_SDS(0, 2, 0, qsgmii)
		SWITCH_PORT_SDS(3, 3, 0, qsgmii)
		SWITCH_PORT_SDS(2, 4, 0, qsgmii)
		SWITCH_PORT_SDS(5, 5, 1, qsgmii)
		SWITCH_PORT_SDS(4, 6, 1, qsgmii)
		SWITCH_PORT_SDS(7, 7, 1, qsgmii)
		SWITCH_PORT_SDS(6, 8, 1, qsgmii)

		SWITCH_PORT(9, 9, internal)
		SWITCH_PORT(8, 10, internal)
		SWITCH_PORT(11, 11, internal)
		SWITCH_PORT(10, 12, internal)
		SWITCH_PORT(13, 13, internal)
		SWITCH_PORT(12, 14, internal)
		SWITCH_PORT(15, 15, internal)
		SWITCH_PORT(14, 16, internal)

		SWITCH_PORT_SDS(17, 17, 2, qsgmii)
		SWITCH_PORT_SDS(16, 18, 2, qsgmii)
		SWITCH_PORT_SDS(19, 19, 2, qsgmii)
		SWITCH_PORT_SDS(18, 20, 2, qsgmii)
		SWITCH_PORT_SDS(21, 21, 3, qsgmii)
		SWITCH_PORT_SDS(20, 22, 3, qsgmii)
		SWITCH_PORT_SDS(23, 23, 3, qsgmii)
		SWITCH_PORT_SDS(22, 24, 3, qsgmii)
	};
};

&gpio1 {
	/delete-node/ poe_enable;
};

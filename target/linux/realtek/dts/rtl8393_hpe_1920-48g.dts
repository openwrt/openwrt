// SPDX-License-Identifier: GPL-2.0-or-later OR MIT

#include "rtl8393_hpe_1920.dtsi"

/ {
	compatible = "hpe,1920-48g", "realtek,rtl8393-soc";
	model = "HPE 1920-48G (JG927A)";

	i2c0: i2c-gpio-0 {
		compatible = "i2c-gpio";
		sda-gpios = <&gpio0 18 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		scl-gpios = <&gpio0 17 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		i2c-gpio,delay-us = <2>;
		#address-cells = <1>;
		#size-cells = <0>;
	};

	sfp0: sfp-p49 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c0>;
		los-gpio = <&gpio0 20 GPIO_ACTIVE_HIGH>;
		mod-def0-gpio = <&gpio0 19 GPIO_ACTIVE_LOW>;
		// tx-fault unconnected (TODO?)
		// tx-disable connected to RTL8214FC (TODO?)
	};

	i2c1: i2c-gpio-1 {
		compatible = "i2c-gpio";
		sda-gpios = <&gpio0 2 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		scl-gpios = <&gpio0 1 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		i2c-gpio,delay-us = <2>;
		#address-cells = <1>;
		#size-cells = <0>;
	};

	sfp1: sfp-p50 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c1>;
		los-gpio = <&gpio0 13 GPIO_ACTIVE_HIGH>;
		mod-def0-gpio = <&gpio0 12 GPIO_ACTIVE_LOW>;
		// tx-fault unconnected (TODO?)
		// tx-disable connected to RTL8214FC (TODO?)
	};

	// not enabled due to shared I2C clock
	i2c2: i2c-gpio-2 {
		status = "disabled";
		compatible = "i2c-gpio";
		sda-gpios = <&gpio0 21 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		scl-gpios = <&gpio0 17 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		i2c-gpio,delay-us = <2>;
		#address-cells = <1>;
		#size-cells = <0>;
	};

	sfp2: sfp-p51 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c2>;
		los-gpio = <&gpio0 23 GPIO_ACTIVE_HIGH>;
		mod-def0-gpio = <&gpio0 22 GPIO_ACTIVE_LOW>;
		// tx-fault unconnected (TODO?)
		// tx-disable connected to RTL8214FC (TODO?)
	};

	// not enabled due to shared I2C clock
	i2c3: i2c-gpio-3 {
		status = "disabled";
		compatible = "i2c-gpio";
		sda-gpios = <&gpio0 14 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		scl-gpios = <&gpio0 1 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		i2c-gpio,delay-us = <2>;
		#address-cells = <1>;
		#size-cells = <0>;
	};

	sfp3: sfp-p52 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c3>;
		los-gpio = <&gpio0 16 GPIO_ACTIVE_HIGH>;
		mod-def0-gpio = <&gpio0 15 GPIO_ACTIVE_LOW>;
		// tx-fault unconnected (TODO?)
		// tx-disable connected to RTL8214FC (TODO?)
	};

};

&ethernet0 {
        mdio: mdio-bus {
		EXTERNAL_SFP_PHY_FULL(48, 1)
		EXTERNAL_SFP_PHY_FULL(49, 3)
		EXTERNAL_SFP_PHY_FULL(50, 0)
		EXTERNAL_SFP_PHY_FULL(51, 2)
	};
};


&switch0 {
        ports {
		SWITCH_PORT(48, 50, qsgmii)
		SWITCH_PORT(49, 52, qsgmii)
		SWITCH_PORT(50, 49, qsgmii)
		SWITCH_PORT(51, 51, qsgmii)
	};
};

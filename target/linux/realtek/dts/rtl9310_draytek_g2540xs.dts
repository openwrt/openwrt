// SPDX-License-Identifier: GPL-2.0-or-later
/dts-v1/;

#include "rtl931x.dtsi"

#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/leds/common.h>
#include <dt-bindings/phy/phy.h>

/ {
	compatible = "draytek,g2540xs", "realtek,rtl9311-soc";
	model = "DrayTek VigorSwitch G2540xs";

	aliases {
		label-mac-device = &ethernet0;
	};

	chosen {
		bootargs = "console=ttyS0,115200";
		stdout-path = "serial0:115200n8";
	};

	memory@0 {
		device_type = "memory";
		reg = <0x00000000 0x10000000>, /* 256 MiB lowmem */
		      <0x90000000 0x10000000>; /* 256 MiB highmem */
	};

	leds {
		compatible = "gpio-leds";

		led-status {
			function = LED_FUNCTION_STATUS;
			gpios = <&gpio1 29 GPIO_ACTIVE_HIGH>;
			default-state = "on";
		};
	};

	sfp0: sfp-p49 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c0>;
	};
	sfp1: sfp-p50 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c1>;
	};
	sfp2: sfp-p51 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c2>;
	};
	sfp3: sfp-p52 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c3>;
	};
	sfp4: sfp-p53 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c4>;
	};
	sfp5: sfp-p54 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c5>;
	};
};

&i2c_mst1 {
	status = "okay";

	i2c0: i2c@0 { reg = <0>; };
	i2c1: i2c@1 { reg = <1>; };
	i2c2: i2c@2 { reg = <2>; };
	i2c3: i2c@3 { reg = <3>; };
	i2c4: i2c@4 { reg = <4>; };
	i2c5: i2c@5 { reg = <5>; };
	i2c6: i2c@6 {
		reg = <6>;
		#address-cells = <1>;
		#size-cells = <0>;

		hwmon@2e {
			compatible = "adi,adt7476";
			reg = <0x2e>;
		};
	};
};

&mdio_aux {
	status = "okay";

	gpio1: gpio@0 {
		compatible = "realtek,rtl8231";
		reg = <0>;

		gpio-controller;
		#gpio-cells = <2>;
		gpio-ranges = <&gpio1 0 0 37>;

		led-controller {
			compatible = "realtek,rtl8231-leds";
			status = "disabled";
		};
	};
};

&spi0 {
	status = "okay";

	flash@0 {
		compatible = "jedec,spi-nor";
		reg = <0>;
		spi-max-frequency = <10000000>;

		partitions {
			compatible = "fixed-partitions";
			#address-cells = <1>;
			#size-cells = <1>;

			partition@0 {
				label = "LOADER";
				reg = <0x000000 0x0E0000>;
				read-only;
			};

			partition@e0000 {
				label = "BDINFO";
				reg = <0x0E0000 0x010000>;
			};

			partition@f0000 {
				label = "SYSINFO";
				reg = <0x0F0000 0x010000>;
			};

			partition@100000 {
				label = "Config";
				reg = <0x100000 0x100000>;
			};

			partition@200000 {
				label = "Factory";
				reg = <0x200000 0x100000>;
			};

			partition@300000 {
				compatible = "openwrt,uimage";
				label = "Kernel";
				reg = <0x300000 0x1E80000>;
			};

			partition@2180000 {
				compatible = "openwrt,uimage";
				label = "Kernel2";
				reg = <0x2180000 0x1E80000>;
			};
		};
	};
};

&mdio_ctrl {
	pinctrl-names = "default";
	pinctrl-0 = <&pinmux_enable_mdc_mdio_0>,
		    <&pinmux_enable_mdc_mdio_1>;
};

&mdio_bus0 {
	ethernet-phy-package@0 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <0>;

		PHY_C22(0, 0)
		PHY_C22(1, 1)
		PHY_C22(2, 2)
		PHY_C22(3, 3)
		PHY_C22(4, 4)
		PHY_C22(5, 5)
		PHY_C22(6, 6)
		PHY_C22(7, 7)
	};
	ethernet-phy-package@8 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <8>;

		PHY_C22(8, 8)
		PHY_C22(9, 9)
		PHY_C22(10, 10)
		PHY_C22(11, 11)
		PHY_C22(12, 12)
		PHY_C22(13, 13)
		PHY_C22(14, 14)
		PHY_C22(15, 15)
	};
	ethernet-phy-package@16 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <16>;

		PHY_C22(16, 16)
		PHY_C22(17, 17)
		PHY_C22(18, 18)
		PHY_C22(19, 19)
		PHY_C22(20, 20)
		PHY_C22(21, 21)
		PHY_C22(22, 22)
		PHY_C22(23, 23)
	};
};

&mdio_bus1 {
	ethernet-phy-package@0 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <0>;

		PHY_C22(24, 0)
		PHY_C22(25, 1)
		PHY_C22(26, 2)
		PHY_C22(27, 3)
		PHY_C22(28, 4)
		PHY_C22(29, 5)
		PHY_C22(30, 6)
		PHY_C22(31, 7)
	};
	ethernet-phy-package@8 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <8>;

		PHY_C22(32, 8)
		PHY_C22(33, 9)
		PHY_C22(34, 10)
		PHY_C22(35, 11)
		PHY_C22(36, 12)
		PHY_C22(37, 13)
		PHY_C22(38, 14)
		PHY_C22(39, 15)
	};
	ethernet-phy-package@16 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <16>;

		PHY_C22(40, 16)
		PHY_C22(41, 17)
		PHY_C22(42, 18)
		PHY_C22(43, 19)
		PHY_C22(44, 20)
		PHY_C22(45, 21)
		PHY_C22(46, 22)
		PHY_C22(47, 23)
	};
};

&switch0 {
	ethernet-ports {
		#address-cells = <1>;
		#size-cells = <0>;

		SWITCH_PORT_SDS(0, 1, 2, 0, usxgmii)
		SWITCH_PORT_SDS(1, 2, 2, 1, usxgmii)
		SWITCH_PORT_SDS(2, 3, 2, 2, usxgmii)
		SWITCH_PORT_SDS(3, 4, 2, 3, usxgmii)
		SWITCH_PORT_SDS(4, 5, 2, 4, usxgmii)
		SWITCH_PORT_SDS(5, 6, 2, 5, usxgmii)
		SWITCH_PORT_SDS(6, 7, 2, 6, usxgmii)
		SWITCH_PORT_SDS(7, 8, 2, 7, usxgmii)

		SWITCH_PORT_SDS(8, 9, 3, 0, usxgmii)
		SWITCH_PORT_SDS(9, 10, 3, 1, usxgmii)
		SWITCH_PORT_SDS(10, 11, 3, 2, usxgmii)
		SWITCH_PORT_SDS(11, 12, 3, 3, usxgmii)
		SWITCH_PORT_SDS(12, 13, 3, 4, usxgmii)
		SWITCH_PORT_SDS(13, 14, 3, 5, usxgmii)
		SWITCH_PORT_SDS(14, 15, 3, 6, usxgmii)
		SWITCH_PORT_SDS(15, 16, 3, 7, usxgmii)

		SWITCH_PORT_SDS(16, 17, 4, 0, usxgmii)
		SWITCH_PORT_SDS(17, 18, 4, 1, usxgmii)
		SWITCH_PORT_SDS(18, 19, 4, 2, usxgmii)
		SWITCH_PORT_SDS(19, 20, 4, 3, usxgmii)
		SWITCH_PORT_SDS(20, 21, 4, 4, usxgmii)
		SWITCH_PORT_SDS(21, 22, 4, 5, usxgmii)
		SWITCH_PORT_SDS(22, 23, 4, 6, usxgmii)
		SWITCH_PORT_SDS(23, 24, 4, 7, usxgmii)

		SWITCH_PORT_SDS(24, 25, 5, 0, usxgmii)
		SWITCH_PORT_SDS(25, 26, 5, 1, usxgmii)
		SWITCH_PORT_SDS(26, 27, 5, 2, usxgmii)
		SWITCH_PORT_SDS(27, 28, 5, 3, usxgmii)
		SWITCH_PORT_SDS(28, 29, 5, 4, usxgmii)
		SWITCH_PORT_SDS(29, 30, 5, 5, usxgmii)
		SWITCH_PORT_SDS(30, 31, 5, 6, usxgmii)
		SWITCH_PORT_SDS(31, 32, 5, 7, usxgmii)

		SWITCH_PORT_SDS(32, 33, 6, 0, usxgmii)
		SWITCH_PORT_SDS(33, 34, 6, 1, usxgmii)
		SWITCH_PORT_SDS(34, 35, 6, 2, usxgmii)
		SWITCH_PORT_SDS(35, 36, 6, 3, usxgmii)
		SWITCH_PORT_SDS(36, 37, 6, 4, usxgmii)
		SWITCH_PORT_SDS(37, 38, 6, 5, usxgmii)
		SWITCH_PORT_SDS(38, 39, 6, 6, usxgmii)
		SWITCH_PORT_SDS(39, 40, 6, 7, usxgmii)

		SWITCH_PORT_SDS(40, 41, 7, 0, usxgmii)
		SWITCH_PORT_SDS(41, 42, 7, 1, usxgmii)
		SWITCH_PORT_SDS(42, 43, 7, 2, usxgmii)
		SWITCH_PORT_SDS(43, 44, 7, 3, usxgmii)
		SWITCH_PORT_SDS(44, 45, 7, 4, usxgmii)
		SWITCH_PORT_SDS(45, 46, 7, 5, usxgmii)
		SWITCH_PORT_SDS(46, 47, 7, 6, usxgmii)
		SWITCH_PORT_SDS(47, 48, 7, 7, usxgmii)

		SWITCH_PORT_SFP(48, 49, 8, 0, 0)
		SWITCH_PORT_SFP(50, 50, 9, 0, 1)
		SWITCH_PORT_SFP(52, 51, 10, 0, 2)
		SWITCH_PORT_SFP(53, 52, 11, 0, 3)
		SWITCH_PORT_SFP(54, 53, 12, 0, 4)
		SWITCH_PORT_SFP(55, 54, 13, 0, 5)

		port@56 {
			ethernet = <&ethernet0>;
			reg = <56>;
			phy-mode = "internal";
			fixed-link {
				speed = <1000>;
				full-duplex;
			};
		};
	};
};

&serdes8 { tx-polarity = <PHY_POL_INVERT>; };
&serdes9 { tx-polarity = <PHY_POL_INVERT>; };
&serdes10 { tx-polarity = <PHY_POL_INVERT>; };
&serdes11 { tx-polarity = <PHY_POL_INVERT>; };
&serdes12 { tx-polarity = <PHY_POL_INVERT>; };
&serdes13 { tx-polarity = <PHY_POL_INVERT>; };

// SPDX-License-Identifier: GPL-2.0-or-later
/dts-v1/;

#include "rtl930x.dtsi"

#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/input/input.h>
#include <dt-bindings/leds/common.h>

/ {
	compatible = "draytek,g2282x", "realtek,rtl9301-soc";
	model = "DrayTek VigorSwitch G2282x";

	aliases {
		label-mac-device = &ethernet0;
		led-boot = &led_status;
		led-failsafe = &led_status;
		led-running = &led_status;
		led-upgrade = &led_status;
	};

	memory@0 {
		device_type = "memory";
		reg = <0x00000000 0x10000000>; /* 256 MiB */
	};

	chosen {
		stdout-path = "serial0:115200n8";
	};

	led_set {
		compatible = "realtek,rtl9300-leds";
		active-low;

		led_set0 = <(RTL93XX_LED_SET_1G | RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)
			    (RTL93XX_LED_SET_10M | RTL93XX_LED_SET_100M |
			     RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)>;
		led_set1 = <(RTL93XX_LED_SET_10G | RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)
			    (RTL93XX_LED_SET_10M | RTL93XX_LED_SET_100M | RTL93XX_LED_SET_1G |
			     RTL93XX_LED_SET_2P5G | RTL93XX_LED_SET_5G |
			     RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)>;
	};

	leds {
		compatible = "gpio-leds";

		led_status: led-status {
			/* Labelled "SYS" on front panel */
			function = LED_FUNCTION_STATUS;
			color = <LED_COLOR_ID_GREEN>;
			gpios = <&gpio1 29 GPIO_ACTIVE_HIGH>;
			default-state = "on";
		};

		led-monitor {
			/* Labelled "MONITOR" on front panel */
			function = "monitor";
			color = <LED_COLOR_ID_RED>;
			gpios = <&gpio2 22 GPIO_ACTIVE_LOW>;
		};
	};

	led-7seg {
		compatible = "gpio-7-segment";
		status = "disabled";
		segment-gpios = <&gpio2 0 GPIO_ACTIVE_LOW>,
				<&gpio2 1 GPIO_ACTIVE_LOW>,
				<&gpio2 2 GPIO_ACTIVE_LOW>,
				<&gpio2 3 GPIO_ACTIVE_LOW>,
				<&gpio2 4 GPIO_ACTIVE_LOW>,
				<&gpio2 5 GPIO_ACTIVE_LOW>,
				<&gpio2 6 GPIO_ACTIVE_LOW>,
				<&gpio2 8 GPIO_ACTIVE_LOW>;
	};

	leds-digit {
		compatible = "gpio-leds";
		status = "disabled";

		led-digit-dot {
			/* Top-left corner dot of the Stack ID display. */
			gpios = <&gpio2 7 GPIO_ACTIVE_LOW>;
		};
	};

	keys {
		compatible = "gpio-keys";

		reset {
			label = "reset";
			gpios = <&gpio2 9 GPIO_ACTIVE_LOW>;
			linux,code = <KEY_RESTART>;
		};

		stack {
			label = "stack";
			gpios = <&gpio2 10 GPIO_ACTIVE_LOW>;
			linux,code = <BTN_0>;
		};
	};

	sfp0: sfp-p25 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c1>;
		mod-def0-gpio = <&gpio1 7 GPIO_ACTIVE_LOW>;
	};
	sfp1: sfp-p26 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c2>;
		mod-def0-gpio = <&gpio1 13 GPIO_ACTIVE_LOW>;
	};
	sfp2: sfp-p27 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c3>;
		mod-def0-gpio = <&gpio1 25 GPIO_ACTIVE_LOW>;
	};
	sfp3: sfp-p28 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c4>;
		mod-def0-gpio = <&gpio1 28 GPIO_ACTIVE_LOW>;
	};
};

&ethernet0 {
	nvmem-cells = <&macaddr_ubootenv_ethaddr 0>;
	nvmem-cell-names = "mac-address";
};

&i2c_mst1 {
	status = "okay";

	i2c0: i2c@0 {
		reg = <0>;
		#address-cells = <1>;
		#size-cells = <0>;

		hwmon@2c {
			compatible = "adi,adt7475";
			reg = <0x2c>;
		};
	};
	i2c1: i2c@2 { reg = <2>; };
	i2c2: i2c@4 { reg = <4>; };
	i2c3: i2c@6 { reg = <6>; };
	i2c4: i2c@7 { reg = <7>; };
};

&mdio_aux {
	status = "okay";

	gpio1: gpio@0 {
		compatible = "realtek,rtl8231";
		reg = <0>;

		gpio-controller;
		#gpio-cells = <2>;
		gpio-ranges = <&gpio1 0 0 37>;

		led-controller {
			compatible = "realtek,rtl8231-leds";
			status = "disabled";
		};
	};

	gpio2: gpio@18 {
		compatible = "realtek,rtl8231";
		reg = <0x18>;

		gpio-controller;
		#gpio-cells = <2>;
		gpio-ranges = <&gpio2 0 0 37>;

		led-controller {
			compatible = "realtek,rtl8231-leds";
			status = "disabled";
		};
	};
};

&spi0 {
	status = "okay";

	flash@0 {
		/*
		 * 64 MiB (partitions below sum to 0x4000000 exactly).
		 * Main/Module SQFS are not separate MTD partitions --
		 * they're embedded inside Kernel/Kernel2 alongside the
		 * initramfs. "openwrt,uimage" on Kernel/Kernel2 lets
		 * mtdsplit_uimage locate the uImage header + trailing
		 * squashfs and auto-mount `rootfs` with no `root=`
		 * bootarg.
		 */
		compatible = "jedec,spi-nor";
		reg = <0>;
		spi-max-frequency = <10000000>;

		partitions {
			compatible = "fixed-partitions";
			#address-cells = <1>;
			#size-cells = <1>;

			partition@0 {
				label = "LOADER";
				reg = <0x000000 0x0E0000>;
				read-only;
			};
			partition@e0000 {
				label = "BDINFO";
				reg = <0x0E0000 0x010000>;
				read-only;

				nvmem-layout {
					compatible = "u-boot,env";

					macaddr_ubootenv_ethaddr: ethaddr {
						#nvmem-cell-cells = <1>;
					};
				};
			};
			partition@f0000 {
				label = "SYSINFO";
				reg = <0x0F0000 0x010000>;
				read-only;
			};
			partition@100000 {
				label = "Config";
				reg = <0x100000 0x100000>;
			};
			partition@200000 {
				label = "Factory";
				reg = <0x200000 0x100000>;
			};
			partition@300000 {
				label = "Kernel";
				compatible = "openwrt,uimage", "denx,uimage";
				reg = <0x300000 0x1E80000>;
			};
			partition@2180000 {
				label = "Kernel2";
				compatible = "openwrt,uimage", "denx,uimage";
				reg = <0x2180000 0x1E80000>;
			};
		};
	};
};

&mdio_bus0 {
	ethernet-phy-package@0 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <0>;

		PHY_C22(0, 0)
		PHY_C22(1, 1)
		PHY_C22(2, 2)
		PHY_C22(3, 3)
		PHY_C22(4, 4)
		PHY_C22(5, 5)
		PHY_C22(6, 6)
		PHY_C22(7, 7)
	};
};

&mdio_bus1 {
	ethernet-phy-package@8 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <8>;

		PHY_C22(8, 8)
		PHY_C22(9, 9)
		PHY_C22(10, 10)
		PHY_C22(11, 11)
		PHY_C22(12, 12)
		PHY_C22(13, 13)
		PHY_C22(14, 14)
		PHY_C22(15, 15)
	};
};

&mdio_bus2 {
	ethernet-phy-package@16 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <16>;

		PHY_C22(16, 16)
		PHY_C22(17, 17)
		PHY_C22(18, 18)
		PHY_C22(19, 19)
		PHY_C22(20, 20)
		PHY_C22(21, 21)
		PHY_C22(22, 22)
		PHY_C22(23, 23)
	};
};

&switch0 {
	ethernet-ports {
		#address-cells = <1>;
		#size-cells = <0>;

		SWITCH_PORT_LED(0, 1, 0, 0, 0, qsgmii)
		SWITCH_PORT_LED(1, 2, 0, 1, 0, qsgmii)
		SWITCH_PORT_LED(2, 3, 0, 2, 0, qsgmii)
		SWITCH_PORT_LED(3, 4, 0, 3, 0, qsgmii)
		SWITCH_PORT_LED(4, 5, 1, 0, 0, qsgmii)
		SWITCH_PORT_LED(5, 6, 1, 1, 0, qsgmii)
		SWITCH_PORT_LED(6, 7, 1, 2, 0, qsgmii)
		SWITCH_PORT_LED(7, 8, 1, 3, 0, qsgmii)

		SWITCH_PORT_LED(8, 9, 2, 0, 0, usxgmii)
		SWITCH_PORT_LED(9, 10, 2, 1, 0, usxgmii)
		SWITCH_PORT_LED(10, 11, 2, 2, 0, usxgmii)
		SWITCH_PORT_LED(11, 12, 2, 3, 0, usxgmii)
		SWITCH_PORT_LED(12, 13, 2, 4, 0, usxgmii)
		SWITCH_PORT_LED(13, 14, 2, 5, 0, usxgmii)
		SWITCH_PORT_LED(14, 15, 2, 6, 0, usxgmii)
		SWITCH_PORT_LED(15, 16, 2, 7, 0, usxgmii)

		SWITCH_PORT_LED(16, 17, 3, 0, 0, usxgmii)
		SWITCH_PORT_LED(17, 18, 3, 1, 0, usxgmii)
		SWITCH_PORT_LED(18, 19, 3, 2, 0, usxgmii)
		SWITCH_PORT_LED(19, 20, 3, 3, 0, usxgmii)
		SWITCH_PORT_LED(20, 21, 3, 4, 0, usxgmii)
		SWITCH_PORT_LED(21, 22, 3, 5, 0, usxgmii)
		SWITCH_PORT_LED(22, 23, 3, 6, 0, usxgmii)
		SWITCH_PORT_LED(23, 24, 3, 7, 0, usxgmii)

		SWITCH_PORT_SFP(24, 25, 4, 1, 0)
		SWITCH_PORT_SFP(25, 26, 6, 1, 1)
		SWITCH_PORT_SFP(26, 27, 8, 1, 2)
		SWITCH_PORT_SFP(27, 28, 9, 1, 3)

		port@28 {
			reg = <28>;
			ethernet = <&ethernet0>;
			phy-mode = "internal";
			fixed-link {
				speed = <1000>;
				full-duplex;
			};
		};
	};
};

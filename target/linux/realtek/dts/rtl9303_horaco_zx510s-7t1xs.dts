// SPDX-License-Identifier: GPL-2.0-or-later

#include "rtl930x.dtsi"

#include <dt-bindings/input/input.h>
#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/leds/common.h>

/ {
	compatible = "horaco,zx510s-7t1xs", "realtek,rtl9303-soc";
	model = "Horaco ZX510S-7T1XS";

	aliases {
		label-mac-device = &ethernet0;
		led-boot = &led_sys;
		led-failsafe = &led_sys;
		led-running = &led_sys;
		led-upgrade = &led_sys;
	};

	chosen {
		bootargs = "console=ttyS0,115200 earlyprintk";
	};

	memory@0 {
		device_type = "memory";
		reg = <0x0 0x8000000>;
	};

	led_set {
		compatible = "realtek,rtl9300-leds";
		realtek,led-mode = <RTL93XX_LED_MODE_SERIAL>;
		active-low;

		/* The board is wired for three LEDs per port; the first is unused. */

		/* RJ45 ports: green 10G, orange 5G/2.5G/1G/100M */
		led_set0 = <RTL93XX_LED_SET_NONE
			    (RTL93XX_LED_SET_10G | RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)
			    (RTL93XX_LED_SET_5G | RTL93XX_LED_SET_2P5G | RTL93XX_LED_SET_1G |
			     RTL93XX_LED_SET_100M | RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)>;

		/* SFP+ port */
		led_set1 = <RTL93XX_LED_SET_NONE
			    (RTL93XX_LED_SET_2P5G | RTL93XX_LED_SET_1G | RTL93XX_LED_SET_100M |
			     RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)
			    (RTL93XX_LED_SET_10G | RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)>;
	};

	leds: leds {
		compatible = "gpio-leds";
		pinctrl-names = "default";
		pinctrl-0 = <&pinmux_disable_sys_led>;

		led_sys: sys {
			color = <LED_COLOR_ID_GREEN>;
			function = LED_FUNCTION_STATUS;
			gpios = <&gpio0 0 GPIO_ACTIVE_LOW>;
		};
	};

	keys {
		compatible = "gpio-keys";

		button-reset {
			label = "reset";
			gpios = <&gpio0 5 GPIO_ACTIVE_LOW>;
			linux,code = <KEY_RESTART>;
		};
	};

	sfp0: sfp-p8 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c_hw2>;
		los-gpios = <&gpio0 12 GPIO_ACTIVE_HIGH>;
		mod-def0-gpios = <&gpio0 13 GPIO_ACTIVE_LOW>;
		tx-disable-gpios = <&gpio0 14 GPIO_ACTIVE_HIGH>;
	};
};

&i2c_mst1 {
	status = "okay";

	i2c_hw0: i2c@0 {
		reg = <0>;
		#address-cells = <1>;
		#size-cells = <0>;

		hwmon@2e {
			compatible = "adi,adt7476";
			reg = <0x2e>;
		};
	};

	i2c_hw2: i2c@2 {
		reg = <2>;
	};
};

&spi0 {
	status = "okay";

	flash@0 {
		compatible = "jedec,spi-nor";
		reg = <0>;
		spi-max-frequency = <50000000>;

		partitions {
			compatible = "fixed-partitions";
			#address-cells = <1>;
			#size-cells = <1>;

			partition@0 {
				label = "loader";
				reg = <0x0 0xe0000>;
				read-only;
			};

			partition@e0000 {
				label = "bdinfo";
				reg = <0xe0000 0x10000>;
				read-only;

				nvmem-layout {
					compatible = "u-boot,env";

					macaddr_ubootenv_ethaddr: ethaddr {
						#nvmem-cell-cells = <1>;
					};
				};
			};

			partition@f0000 {
				label = "sysinfo";
				reg = <0xf0000 0x10000>;
				read-only;
			};

			partition@100000 {
				label = "jffs2-cfg";
				reg = <0x100000 0x100000>;
				read-only;
			};

			partition@200000 {
				label = "jffs2-log";
				reg = <0x200000 0x100000>;
				read-only;
			};

			/* stock is "runtime" */
			partition@300000 {
				label = "firmware";
				reg = <0x300000 0xc00000>;
				compatible = "openwrt,uimage", "denx,uimage";
				openwrt,ih-magic = <0x83800000>;
			};

			partition@f00000 {
				label = "oeminfo";
				reg = <0xf00000 0x100000>;
				read-only;
			};
		};
	};
};

&ethernet0 {
	nvmem-cells = <&macaddr_ubootenv_ethaddr 0>;
	nvmem-cell-names = "mac-address";
};

/* RTL8264B */
&mdio_bus0 {
	ethernet-phy-package@0 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <0>;

		PHY_C45(0, 0)
		PHY_C45(8, 1)
		PHY_C45(16, 2)
		PHY_C45(20, 3)
	};
};

/* RTL8261BE */
&mdio_bus1 {
	PHY_C45(24, 0)
};

/* RTL8261BE */
&mdio_bus2 {
	PHY_C45(25, 0)
};

/* RTL8261BE */
&mdio_bus3 {
	PHY_C45(26, 0)
};

&switch0 {
	ethernet-ports {
		#address-cells = <1>;
		#size-cells = <0>;

		SWITCH_PORT_LED(0, 1, 2, 0, 0, usxgmii)
		SWITCH_PORT_LED(8, 2, 3, 0, 0, usxgmii)
		SWITCH_PORT_LED(16, 3, 4, 0, 0, usxgmii)
		SWITCH_PORT_LED(20, 4, 5, 0, 0, usxgmii)
		SWITCH_PORT_LED(24, 5, 6, 0, 0, usxgmii)
		SWITCH_PORT_LED(25, 6, 7, 0, 0, usxgmii)
		SWITCH_PORT_LED(26, 7, 8, 0, 0, usxgmii)
		SWITCH_PORT_SFP(27, 8, 9, 1, 0)

		port@1c {
			reg = <28>;
			ethernet = <&ethernet0>;
			phy-mode = "internal";
			fixed-link {
				speed = <1000>;
				full-duplex;
			};
		};
	};
};

// SPDX-License-Identifier: GPL-2.0-or-later

#include "rtl8380_zyxel_gs1900.dtsi"
#include "rtl8380_zyxel_gs1900_gpio.dtsi"

/ {
	compatible = "zyxel,gs1900-16-a1", "realtek,rtl838x-soc";
	model = "Zyxel GS1900-16 A1";
};

&mdio_bus0 {
	EXTERNAL_PHY(16)
	EXTERNAL_PHY(17)
	EXTERNAL_PHY(18)
	EXTERNAL_PHY(19)
	EXTERNAL_PHY(20)
	EXTERNAL_PHY(21)
	EXTERNAL_PHY(22)
	EXTERNAL_PHY(23)
};

&switch0 {
	ports {
		SWITCH_PORT_SDS(16, 9, 2, qsgmii)
		SWITCH_PORT_SDS(17, 10, 2, qsgmii)
		SWITCH_PORT_SDS(18, 11, 2, qsgmii)
		SWITCH_PORT_SDS(19, 12, 2, qsgmii)
		SWITCH_PORT_SDS(20, 13, 3, qsgmii)
		SWITCH_PORT_SDS(21, 14, 3, qsgmii)
		SWITCH_PORT_SDS(22, 15, 3, qsgmii)
		SWITCH_PORT_SDS(23, 16, 3, qsgmii)
	};
};

&gpio1 {
	/delete-node/ poe_enable;
};

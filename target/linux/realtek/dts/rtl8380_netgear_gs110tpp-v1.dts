// SPDX-License-Identifier: GPL-2.0-or-later

#include "rtl8380_netgear_gigabit.dtsi"
#include <dt-bindings/leds/common.h>

/ {
	compatible = "netgear,gs110tpp-v1", "realtek,rtl838x-soc";
	model = "Netgear GS110TPP v1";

	aliases {
		led-boot = &led_status_green;
		led-failsafe = &led_status_red;
		led-running = &led_status_green;
		led-upgrade = &led_status_blue;
	};

	leds {
		compatible = "gpio-leds";

		led_status_red: led-0 {
			color = <LED_COLOR_ID_RED>;
			function = LED_FUNCTION_STATUS;
			gpios = <&gpio1 31 GPIO_ACTIVE_LOW>;
		};

		led_status_green: led-1 {
			color = <LED_COLOR_ID_GREEN>;
			function = LED_FUNCTION_STATUS;
			gpios = <&gpio1 32 GPIO_ACTIVE_LOW>;
		};

		led_status_blue: led-2 {
			color = <LED_COLOR_ID_BLUE>;
			function = LED_FUNCTION_STATUS;
			gpios = <&gpio1 34 GPIO_ACTIVE_LOW>;
		};
	};
};

&gpio1 {
	poe-enable {
		gpio-hog;
		gpios = <10 GPIO_ACTIVE_HIGH>;
		output-high;
		line-name = "poe-enable";
	};
};

&firmware {
	openwrt,ih-magic = <0x4e474520>;
};

&uart1 {
	status = "okay";

	pse: ethernet-pse {
		compatible = "netgear,gs110tpp-v1-pse", "realtek,pse-mcu-gen1";
		current-speed = <19200>;

		pse-pis {
			#address-cells = <1>;
			#size-cells = <0>;

			PSE_PI(0)
			PSE_PI(1)
			PSE_PI(2)
			PSE_PI(3)
			PSE_PI(4)
			PSE_PI(5)
			PSE_PI(6)
			PSE_PI(7)
		};
	};
};

/* Copper ports lan1..lan8 (phy8..phy15) -> MCU PoE ports 0..7 */
&phy8  { pses = <&pse_pi0>; };
&phy9  { pses = <&pse_pi1>; };
&phy10 { pses = <&pse_pi2>; };
&phy11 { pses = <&pse_pi3>; };
&phy12 { pses = <&pse_pi4>; };
&phy13 { pses = <&pse_pi5>; };
&phy14 { pses = <&pse_pi6>; };
&phy15 { pses = <&pse_pi7>; };

&mdio_bus0 {
	PHY_C22(16, 16)
	PHY_C22(17, 17)
};

&switch0 {
	ethernet-ports {
		SWITCH_PORT_SDS(16, 9, 2, 0, qsgmii)
		SWITCH_PORT_SDS(17, 10, 2, 1, qsgmii)
	};
};

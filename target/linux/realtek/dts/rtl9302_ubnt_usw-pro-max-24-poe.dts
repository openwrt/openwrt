// SPDX-License-Identifier: GPL-2.0-or-later
/dts-v1/;

#include "rtl9302_ubnt_usw-pro-max-common.dtsi"

/ {
	compatible = "ubnt,usw-pro-max-24-poe", "realtek,rtl9302b-soc";
	model = "UniFi USW Pro Max 24 PoE";
};

&pse {
	compatible = "ubnt,usw-pro-max-24-poe-pse", "realtek,pse-mcu-gen2-smbus";

	pse-pis {
		PSE_PI(0)
		PSE_PI(1)
		PSE_PI(2)
		PSE_PI(3)
		PSE_PI(4)
		PSE_PI(5)
		PSE_PI(6)
		PSE_PI(7)
		PSE_PI(8)
		PSE_PI(9)
		PSE_PI(10)
		PSE_PI(11)
		PSE_PI(12)
		PSE_PI(13)
		PSE_PI(14)
		PSE_PI(15)
		PSE_PI(16)
		PSE_PI(17)
		PSE_PI(18)
		PSE_PI(19)
		PSE_PI(20)
		PSE_PI(21)
		PSE_PI(22)
		PSE_PI(23)
	};
};

&mdio_bus2 {
	/* RTL8224 */
	ethernet-phy-package@0 {
		reg = <0>;
		#address-cells = <1>;
		#size-cells = <0>;

		PHY_C45(16, 0)
		PHY_C45(17, 1)
		PHY_C45(18, 2)
		PHY_C45(19, 3)
	};

	/* RTL8224 */
	ethernet-phy-package@4 {
		reg = <4>;
		#address-cells = <1>;
		#size-cells = <0>;

		PHY_C45(20, 4)
		PHY_C45(21, 5)
		PHY_C45(22, 6)
		PHY_C45(23, 7)
	};
};

&switch0 {
	ethernet-ports {
		SWITCH_PORT_LED(0, 1, 2, 0, 0, usxgmii)
		SWITCH_PORT_LED(1, 2, 2, 1, 0, usxgmii)
		SWITCH_PORT_LED(2, 3, 2, 2, 0, usxgmii)
		SWITCH_PORT_LED(3, 4, 2, 3, 0, usxgmii)
		SWITCH_PORT_LED(4, 5, 2, 4, 0, usxgmii)
		SWITCH_PORT_LED(5, 6, 2, 5, 0, usxgmii)
		SWITCH_PORT_LED(6, 7, 2, 6, 0, usxgmii)
		SWITCH_PORT_LED(7, 8, 2, 7, 0, usxgmii)

		SWITCH_PORT_LED(8, 9, 3, 0, 0, usxgmii)
		SWITCH_PORT_LED(9, 10, 3, 1, 0, usxgmii)
		SWITCH_PORT_LED(10, 11, 3, 2, 0, usxgmii)
		SWITCH_PORT_LED(11, 12, 3, 3, 0, usxgmii)
		SWITCH_PORT_LED(12, 13, 3, 4, 0, usxgmii)
		SWITCH_PORT_LED(13, 14, 3, 5, 0, usxgmii)
		SWITCH_PORT_LED(14, 15, 3, 6, 0, usxgmii)
		SWITCH_PORT_LED(15, 16, 3, 7, 0, usxgmii)

		SWITCH_PORT_LED(16, 17, 4, 0, 0, 10g-qxgmii)
		SWITCH_PORT_LED(17, 18, 4, 1, 0, 10g-qxgmii)
		SWITCH_PORT_LED(18, 19, 4, 2, 0, 10g-qxgmii)
		SWITCH_PORT_LED(19, 20, 4, 3, 0, 10g-qxgmii)

		SWITCH_PORT_LED(20, 21, 5, 0, 0, 10g-qxgmii)
		SWITCH_PORT_LED(21, 22, 5, 1, 0, 10g-qxgmii)
		SWITCH_PORT_LED(22, 23, 5, 2, 0, 10g-qxgmii)
		SWITCH_PORT_LED(23, 24, 5, 3, 0, 10g-qxgmii)

		SWITCH_PORT_SFP(24, 25, 6, 0, 1)
		SWITCH_PORT_SFP(25, 26, 7, 0, 2)
	};
};

&phy0 { pses = <&pse_pi0>; };
&phy1 { pses = <&pse_pi1>; };
&phy2 { pses = <&pse_pi2>; };
&phy3 { pses = <&pse_pi3>; };
&phy4 { pses = <&pse_pi4>; };
&phy5 { pses = <&pse_pi5>; };
&phy6 { pses = <&pse_pi6>; };
&phy7 { pses = <&pse_pi7>; };
&phy8 { pses = <&pse_pi8>; };
&phy9 { pses = <&pse_pi9>; };
&phy10 { pses = <&pse_pi10>; };
&phy11 { pses = <&pse_pi11>; };
&phy12 { pses = <&pse_pi12>; };
&phy13 { pses = <&pse_pi13>; };
&phy14 { pses = <&pse_pi14>; };
&phy15 { pses = <&pse_pi15>; };
&phy16 { pses = <&pse_pi16>; };
&phy17 { pses = <&pse_pi17>; };
&phy18 { pses = <&pse_pi18>; };
&phy19 { pses = <&pse_pi19>; };
&phy20 { pses = <&pse_pi20>; };
&phy21 { pses = <&pse_pi21>; };
&phy22 { pses = <&pse_pi22>; };
&phy23 { pses = <&pse_pi23>; };

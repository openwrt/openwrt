// SPDX-License-Identifier: GPL-2.0-or-later
/dts-v1/;

#include "rtl931x.dtsi"

#include <dt-bindings/input/input.h>
#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/leds/common.h>
#include <dt-bindings/mux/mux.h>

/ {
	compatible = "zyxel,xgs2220-30hp", "realtek,rtl9311-soc";
	model = "Zyxel XGS2220-30HP";

	aliases {
		label-mac-device = &ethernet0;
		led-boot = &led_sys_green;
		led-failsafe = &led_sys_orange;
		led-running = &led_sys_green;
		led-upgrade = &led_sys_green;
	};

	chosen {
		bootargs = "console=ttyS0,115200 earlycon";
	};

	memory@0 {
		device_type = "memory";
		reg = <0x00000000 0x10000000>,
		      <0x90000000 0x30000000>;
	};

	keys {
		compatible = "gpio-keys";

		key-restore {
			label = "restore";
			gpios = <&gpio0 28 GPIO_ACTIVE_LOW>;
			linux,code = <BTN_0>;
		};
	};

	leds: leds {
		compatible = "gpio-leds";
		pinctrl-names = "default";
		pinctrl-0 = <&pinmux_disable_sys_led>;

		led_sys_green: led-0 {
			color = <LED_COLOR_ID_GREEN>;
			function = LED_FUNCTION_INDICATOR;
			gpios = <&gpio0 0 GPIO_ACTIVE_HIGH>;
		};

		led_sys_orange: led-1 {
			color = <LED_COLOR_ID_ORANGE>;
			function = LED_FUNCTION_INDICATOR;
			gpios = <&gpio0 30 GPIO_ACTIVE_HIGH>;
		};

		led_poe_max_orange: led-2 {
			color = <LED_COLOR_ID_ORANGE>;
			function = "poe-max";
			gpios = <&gpio1 16 GPIO_ACTIVE_LOW>;
		};
		led_poe_max_red: led-3 {
			color = <LED_COLOR_ID_RED>;
			function = "poe-max";
			gpios = <&gpio1 17 GPIO_ACTIVE_LOW>;
		};
		led_locator: led-4 {
			color = <LED_COLOR_ID_BLUE>;
			function = "locator";
			gpios = <&gpio1 18 GPIO_ACTIVE_LOW>;
		};
		led_primary_green: led-5 {
			color = <LED_COLOR_ID_GREEN>;
			function = "primary";
			gpios = <&gpio1 32 GPIO_ACTIVE_LOW>;
		};
		led_primary_orange: led-6 {
			color = <LED_COLOR_ID_ORANGE>;
			function = "primary";
			gpios = <&gpio1 33 GPIO_ACTIVE_LOW>;
		};
		led_cloud_green: led-7 {
			color = <LED_COLOR_ID_GREEN>;
			function = "cloud";
			gpios = <&gpio1 35 GPIO_ACTIVE_HIGH>;
		};
		led_cloud_red: led-8 {
			color = <LED_COLOR_ID_RED>;
			function = "cloud";
			gpios = <&gpio1 36 GPIO_ACTIVE_HIGH>;
		};
	};

	led_set: led_set@0 {
		compatible = "realtek,rtl9300-leds";
		active-low;

		/*
		 * LED set for RTL8218E ports; link/activity LEDs are controlled
		 * by the PHYs, PoE LEDs remain controlled by the switch
		 */
		led_set0 = <RTL93XX_LED_SET_NONE RTL93XX_LED_SET_NONE>;
		led_set1 = <(RTL93XX_LED_SET_10G | RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)
			    (RTL93XX_LED_SET_5G | RTL93XX_LED_SET_2P5G | RTL93XX_LED_SET_1G |
			     RTL93XX_LED_SET_100M | RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)
			    RTL93XX_LED_SET_NONE RTL93XX_LED_SET_NONE>;
		led_set2 = <(RTL93XX_LED_SET_10G | RTL93XX_LED_SET_5G | RTL93XX_LED_SET_2P5G |
			     RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)
			    (RTL93XX_LED_SET_1G | RTL93XX_LED_SET_100M | RTL93XX_LED_SET_10M |
			     RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)>;
	};

	sfp0: sfp-p27 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c_sfp27>;
		mod-def0-gpios = <&gpio0 8 GPIO_ACTIVE_LOW>;
		los-gpios = <&gpio1 4 GPIO_ACTIVE_HIGH>;
		tx-disable-gpios = <&gpio1 0 GPIO_ACTIVE_HIGH>;
		tx-fault-gpios = <&gpio1 8 GPIO_ACTIVE_HIGH>;
	};

	sfp1: sfp-p28 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c_sfp28>;
		mod-def0-gpios = <&gpio0 9 GPIO_ACTIVE_LOW>;
		los-gpios = <&gpio1 5 GPIO_ACTIVE_HIGH>;
		tx-disable-gpios = <&gpio1 1 GPIO_ACTIVE_HIGH>;
		tx-fault-gpios = <&gpio1 9 GPIO_ACTIVE_HIGH>;
	};

	sfp2: sfp-p29 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c_sfp29>;
		mod-def0-gpios = <&gpio0 25 GPIO_ACTIVE_LOW>;
		los-gpios = <&gpio1 6 GPIO_ACTIVE_HIGH>;
		tx-disable-gpios = <&gpio1 2 GPIO_ACTIVE_HIGH>;
		tx-fault-gpios = <&gpio1 10 GPIO_ACTIVE_HIGH>;
	};

	sfp3: sfp-p30 {
		compatible = "sff,sfp";
		i2c-bus = <&i2c_sfp30>;
		mod-def0-gpios = <&gpio0 26 GPIO_ACTIVE_LOW>;
		los-gpios = <&gpio1 7 GPIO_ACTIVE_HIGH>;
		tx-disable-gpios = <&gpio1 3 GPIO_ACTIVE_HIGH>;
		tx-fault-gpios = <&gpio1 11 GPIO_ACTIVE_HIGH>;
	};

	led-7seg {
		compatible = "gpio-7-segment";
		segment-gpios = <&gpio1 22 GPIO_ACTIVE_LOW>,
				<&gpio1 23 GPIO_ACTIVE_LOW>,
				<&gpio1 24 GPIO_ACTIVE_LOW>,
				<&gpio1 25 GPIO_ACTIVE_LOW>,
				<&gpio1 26 GPIO_ACTIVE_LOW>,
				<&gpio1 27 GPIO_ACTIVE_LOW>,
				<&gpio1 28 GPIO_ACTIVE_LOW>,
				<&gpio1 29 GPIO_ACTIVE_LOW>;
	};

	fan0: gpio-fan {
		compatible = "gpio-fan";
		gpios = <&gpio0 12 GPIO_ACTIVE_HIGH>;

		gpio-fan,speed-map =
			<3600 0>,
			<9000 1>;
		#cooling-cells = <2>;
	};
};

&spi0 {
	status = "okay";

	flash@0 {
		compatible = "jedec,spi-nor";
		reg = <0>;

		partitions {
			compatible = "fixed-partitions";
			#address-cells = <1>;
			#size-cells = <1>;

			partition@0 {
				label = "BootBase";
				reg = <0x0 0xa0000>;
				read-only;

				nvmem-layout {
					compatible = "fixed-layout";
					#address-cells = <1>;
					#size-cells = <1>;

					factory_macaddr: macaddr@9fff8 {
						reg = <0x9fff8 0x6>;
					};
				};
			};

			/* DbgArea */
			partition@a0000 {
				label = "reserved";
				reg = <0xa0000 0x20000>;
				read-only;
			};

			partition@c0000 {
				label = "RomDir2";
				reg = <0xc0000 0x120000>;
				read-only;

				/* boot image index at offset 0x151 */
				nvmem-layout {
					compatible = "fixed-layout";
					#address-cells = <1>;
					#size-cells = <1>;

					boot_selector: boot-selector@151 {
						reg = <0x151 0x1>;
					};
				};
			};

			/* LogArea1 + LogArea2 + License + GenFS + LogArea3 + Reserved */
			partition@1e0000 {
				label = "reserved2";
				reg = <0x1e0000 0xa0000>;
				read-only;
			};

			partition@280000 {
				reg = <0x280000 0x1d80000>;
				label = "factory";

				compatible = "fixed-partitions";
				#address-cells = <1>;
				#size-cells = <1>;

				partition@0 {
					label = "loader";
					reg = <0x0 0x10000>;
				};

				partition@10000 {
					label = "firmware";
					reg = <0x10000 0x1d70000>;
					compatible = "openwrt,uimage", "denx,uimage";
				};
			};
		};
	};

	flash@1 {
		compatible = "jedec,spi-nor";
		reg = <1>;
		/*
		 * Secondary boot flash with the same partition layout as flash@0.
		 * Expose the whole chip for raw backups until this is used.
		 */
	};
};

&mdio_aux {
	status = "okay";

	gpio1: gpio@1f {
		compatible = "realtek,rtl8231";
		reg = <0x1f>;

		gpio-controller;
		#gpio-cells = <2>;
		gpio-ranges = <&gpio1 0 0 37>;

		led-controller {
			compatible = "realtek,rtl8231-leds";
			status = "disabled";
		};

		sfp_enable_hog {
			gpio-hog;
			gpios = <12 GPIO_ACTIVE_LOW>, /* SFP27 */
				<13 GPIO_ACTIVE_LOW>, /* SFP28 */
				<14 GPIO_ACTIVE_LOW>, /* SFP29 */
				<21 GPIO_ACTIVE_LOW>; /* SFP30 */
			output-high;
			line-name = "sfp-enable";
		};
	};
};

&ethernet0 {
	nvmem-cells = <&factory_macaddr 0>;
	nvmem-cell-names = "mac-address";
};

&gpio0 {
	pinctrl-names = "default";
	pinctrl-0 = <&pinmux_disable_jtag>;

	/*
	 * GPIO 31 is the global reset pin shared by all PHYs across all MDIO
	 * busses. It is intentionally not declared as reset-gpios on any bus:
	 * the MDIO driver / phylink only support a reset GPIO per bus, not on
	 * the parent controller. Attaching it to a single bus would still reset
	 * the PHYs on the other busses as a side effect, leaving their software
	 * state out of sync with the hardware and likely breaking them.
	 */
	phy_reset_hog {
		gpio-hog;
		gpios = <31 GPIO_ACTIVE_LOW>;
		output-low;
		line-name = "phy-reset";
	};
};

&i2c_mst1 {
	status = "okay";

	i2c0: i2c@0 {
		reg = <0>;
		#address-cells = <1>;
		#size-cells = <0>;

		i2c-mux@70 {
			compatible = "nxp,pca9546";
			#address-cells = <1>;
			#size-cells = <0>;
			reg = <0x70>;

			i2c_sfp27: i2c@0 {
				#address-cells = <1>;
				#size-cells = <0>;
				reg = <0>;
			};
			i2c_sfp28: i2c@1 {
				#address-cells = <1>;
				#size-cells = <0>;
				reg = <1>;
			};
			i2c_sfp29: i2c@2 {
				#address-cells = <1>;
				#size-cells = <0>;
				reg = <2>;
			};
			i2c_sfp30: i2c@3 {
				#address-cells = <1>;
				#size-cells = <0>;
				reg = <3>;
			};
		};
	};
};

&i2c_mst2 {
	status = "okay";

	i2c7: i2c@7 {
		reg = <7>;
		#address-cells = <1>;
		#size-cells = <0>;

		lm96000: lm96000@2e {
			compatible = "national,lm85";
			reg = <0x2e>;
		};
	};
};

&mdio_bus0 {
	/* RTL8218E */
	ethernet-phy-package@0 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <0>;

		PHY_C22(0, 0)
		PHY_C22(1, 1)
		PHY_C22(2, 2)
		PHY_C22(3, 3)
		PHY_C22(4, 4)
		PHY_C22(5, 5)
		PHY_C22(6, 6)
		PHY_C22(7, 7)
	};

	/* RTL8218E */
	ethernet-phy-package@8 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <8>;

		PHY_C22(8, 8)
		PHY_C22(9, 9)
		PHY_C22(10, 10)
		PHY_C22(11, 11)
		PHY_C22(12, 12)
		PHY_C22(13, 13)
		PHY_C22(14, 14)
		PHY_C22(15, 15)
	};

	/* RTL8218E */
	ethernet-phy-package@24 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <24>;

		PHY_C22(16, 24)
		PHY_C22(17, 25)
		PHY_C22(18, 26)
		PHY_C22(19, 27)
		PHY_C22(20, 28)
		PHY_C22(21, 29)
		PHY_C22(22, 30)
		PHY_C22(23, 31)
	};
};

&mdio_bus2 {
	/* AQR113C */
	PHY_C45(48, 0)
	PHY_C45(50, 8)
};

&switch0 {
	ethernet-ports {
		#address-cells = <1>;
		#size-cells = <0>;

		SWITCH_PORT_SDS(0, 1, 2, 0, usxgmii)
		SWITCH_PORT_SDS(1, 2, 2, 1, usxgmii)
		SWITCH_PORT_SDS(2, 3, 2, 2, usxgmii)
		SWITCH_PORT_SDS(3, 4, 2, 3, usxgmii)
		SWITCH_PORT_SDS(4, 5, 2, 4, usxgmii)
		SWITCH_PORT_SDS(5, 6, 2, 5, usxgmii)
		SWITCH_PORT_SDS(6, 7, 2, 6, usxgmii)
		SWITCH_PORT_SDS(7, 8, 2, 7, usxgmii)

		SWITCH_PORT_SDS(8, 9, 3, 0, usxgmii)
		SWITCH_PORT_SDS(9, 10, 3, 1, usxgmii)
		SWITCH_PORT_SDS(10, 11, 3, 2, usxgmii)
		SWITCH_PORT_SDS(11, 12, 3, 3, usxgmii)
		SWITCH_PORT_SDS(12, 13, 3, 4, usxgmii)
		SWITCH_PORT_SDS(13, 14, 3, 5, usxgmii)
		SWITCH_PORT_SDS(14, 15, 3, 6, usxgmii)
		SWITCH_PORT_SDS(15, 16, 3, 7, usxgmii)

		SWITCH_PORT_SDS(16, 17, 4, 0, usxgmii)
		SWITCH_PORT_SDS(17, 18, 4, 1, usxgmii)
		SWITCH_PORT_SDS(18, 19, 4, 2, usxgmii)
		SWITCH_PORT_SDS(19, 20, 4, 3, usxgmii)
		SWITCH_PORT_SDS(20, 21, 4, 4, usxgmii)
		SWITCH_PORT_SDS(21, 22, 4, 5, usxgmii)
		SWITCH_PORT_SDS(22, 23, 4, 6, usxgmii)
		SWITCH_PORT_SDS(23, 24, 4, 7, usxgmii)

		SWITCH_PORT_LED(48, 25, 8, 0, 1, usxgmii)
		SWITCH_PORT_LED(50, 26, 9, 0, 1, usxgmii)

		SWITCH_PORT_SFP(52, 27, 10, 2, 0)
		SWITCH_PORT_SFP(53, 28, 11, 2, 1)
		SWITCH_PORT_SFP(54, 29, 12, 2, 2)
		SWITCH_PORT_SFP(55, 30, 13, 2, 3)

		/* CPU port */
		port@56 {
			ethernet = <&ethernet0>;
			reg = <56>;
			phy-mode = "internal";
			fixed-link {
				speed = <1000>;
				full-duplex;
			};
		};
	};
};

&port48 { managed = "in-band-status"; };
&port50 { managed = "in-band-status"; };

&mdio_ctrl {
	pinctrl-names = "default";
	pinctrl-0 = <&pinmux_enable_mdc_mdio_0>,
		    <&pinmux_enable_mdc_mdio_2>;
};

&uart1 {
	status = "okay";

	pse: ethernet-pse {
		compatible = "zyxel,xgs2220-30hp-pse", "realtek,pse-mcu-gen2";
		current-speed = <115200>;

		pse-pis {
			#address-cells = <1>;
			#size-cells = <0>;

			PSE_PI(0)
			PSE_PI(1)
			PSE_PI(2)
			PSE_PI(3)
			PSE_PI(4)
			PSE_PI(5)
			PSE_PI(6)
			PSE_PI(7)
			PSE_PI(8)
			PSE_PI(9)
			PSE_PI(10)
			PSE_PI(11)
			PSE_PI(12)
			PSE_PI(13)
			PSE_PI(14)
			PSE_PI(15)
			PSE_PI(16)
			PSE_PI(17)
			PSE_PI(18)
			PSE_PI(19)
			PSE_PI(20)
			PSE_PI(21)
			PSE_PI(22)
			PSE_PI(23)
			PSE_PI(24)
			PSE_PI(25)
		};
	};
};

&phy0 { pses = <&pse_pi0>; };
&phy1 { pses = <&pse_pi1>; };
&phy2 { pses = <&pse_pi2>; };
&phy3 { pses = <&pse_pi3>; };
&phy4 { pses = <&pse_pi4>; };
&phy5 { pses = <&pse_pi5>; };
&phy6 { pses = <&pse_pi6>; };
&phy7 { pses = <&pse_pi7>; };

&phy8 { pses = <&pse_pi8>; };
&phy9 { pses = <&pse_pi9>; };
&phy10 { pses = <&pse_pi10>; };
&phy11 { pses = <&pse_pi11>; };
&phy12 { pses = <&pse_pi12>; };
&phy13 { pses = <&pse_pi13>; };
&phy14 { pses = <&pse_pi14>; };
&phy15 { pses = <&pse_pi15>; };

&phy16 { pses = <&pse_pi16>; };
&phy17 { pses = <&pse_pi17>; };
&phy18 { pses = <&pse_pi18>; };
&phy19 { pses = <&pse_pi19>; };
&phy20 { pses = <&pse_pi20>; };
&phy21 { pses = <&pse_pi21>; };
&phy22 { pses = <&pse_pi22>; };
&phy23 { pses = <&pse_pi23>; };

&phy48 { pses = <&pse_pi24>; };
&phy50 { pses = <&pse_pi25>; };

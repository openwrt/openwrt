// SPDX-License-Identifier: GPL-2.0-or-later
/dts-v1/;

#include "rtl930x.dtsi"
#include <dt-bindings/leds/common.h>
#include <dt-bindings/input/input.h>
#include <dt-bindings/gpio/gpio.h>

/ {
	compatible = "mokerlink,2g080gm", "realtek,rtl9303-soc";
	model = "MokerLink 2G080GM";

	/* rtl930x.dtsi defaults to 128 MiB, matching the stock firmware. */

	aliases {
		led-boot = &led_sys;
		led-failsafe = &led_sys;
		led-running = &led_sys;
		led-upgrade = &led_sys;
		label-mac-device = &ethernet0;
	};

	chosen {
		stdout-path = "serial0:38400n8";
	};

	keys {
		compatible = "gpio-keys";

		button-reset {
			label = "reset";
			gpios = <&gpio0 5 GPIO_ACTIVE_LOW>;
			linux,code = <KEY_RESTART>;
		};
	};

	leds {
		compatible = "gpio-leds";

		pinctrl-names = "default";
		pinctrl-0 = <&pinmux_disable_sys_led>, <&pinmux_enable_led_sync>;

		led_sys: led-0 {
			color = <LED_COLOR_ID_GREEN>;
			function = LED_FUNCTION_STATUS;
			gpios = <&gpio0 0 GPIO_ACTIVE_HIGH>;
		};
	};

	led_set: led_set {
		compatible = "realtek,rtl9300-leds";

		/* [green](left) [green](right) [orange](left) */
		led_set0 = <(RTL93XX_LED_SET_1G | RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)
			    (RTL93XX_LED_SET_100M | RTL93XX_LED_SET_10M | RTL93XX_LED_SET_LINK |
			     RTL93XX_LED_SET_ACT)
			    (RTL93XX_LED_SET_2P5G | RTL93XX_LED_SET_LINK | RTL93XX_LED_SET_ACT)>;
	};
};

&spi0 {
	status = "okay";

	flash@0 {
		compatible = "fudan,fm25q128", "jedec,spi-nor";
		reg = <0>;
		spi-max-frequency = <10000000>;

		partitions {
			compatible = "fixed-partitions";
			#address-cells = <1>;
			#size-cells = <1>;

			partition@0 {
				label = "u-boot";
				reg = <0x0000000 0x00e0000>;
				read-only;
			};

			partition@e0000 {
				label = "u-boot-env";
				reg = <0x00e0000 0x0010000>;

				nvmem-layout {
					compatible = "u-boot,env";
					macaddr_ubootenv_ethaddr: ethaddr {
						#nvmem-cell-cells = <1>;
					};
					serialnumber_ubootenv: serialnumber {
						#nvmem-cell-cells = <1>;
					};
				};
			};

			partition@f0000 {
				label = "u-boot-env2";
				reg = <0x00f0000 0x0010000>;
				read-only;
			};

			partition@100000 {
				label = "jffs";
				reg = <0x0100000 0x0100000>;
			};

			partition@200000 {
				label = "jffs2";
				reg = <0x0200000 0x0100000>;
			};

			partition@300000 {
				compatible = "openwrt,uimage", "denx,uimage";
				openwrt,ih-magic = <0x83800000>;
				label = "firmware";
				reg = <0x0300000 0x0c00000>;
			};

			partition@f00000 {
				label = "oeminfo";
				reg = <0x0f00000 0x0100000>;
				read-only;
			};
		};
	};
};

&ethernet0 {
	nvmem-cells = <&macaddr_ubootenv_ethaddr 0>;
	nvmem-cell-names = "mac-address";
};

&mdio_bus0 {
	PHY_C45(0, 1)
	PHY_C45(8, 2)
	PHY_C45(16, 3)
	PHY_C45(20, 4)
};

&mdio_bus1 {
	PHY_C45(24, 1)
	PHY_C45(25, 2)
	PHY_C45(26, 3)
	PHY_C45(27, 4)
};

&switch0 {
	ethernet-ports {
		#address-cells = <1>;
		#size-cells = <0>;

		port@0 {
			reg = <0>;
			label = "lan1";
			pcs-handle = <&serdes2 0>;
			phy-handle = <&phy0>;
			phy-mode = "sgmii";
			managed = "in-band-status";
		};

		port@8 {
			reg = <8>;
			label = "lan2";
			pcs-handle = <&serdes3 0>;
			phy-handle = <&phy8>;
			phy-mode = "sgmii";
			managed = "in-band-status";
		};

		port@16 {
			reg = <16>;
			label = "lan3";
			pcs-handle = <&serdes4 0>;
			phy-handle = <&phy16>;
			phy-mode = "sgmii";
			managed = "in-band-status";
		};

		port@20 {
			reg = <20>;
			label = "lan4";
			pcs-handle = <&serdes5 0>;
			phy-handle = <&phy20>;
			phy-mode = "sgmii";
			managed = "in-band-status";
		};

		port@24 {
			reg = <24>;
			label = "lan5";
			pcs-handle = <&serdes6 0>;
			phy-handle = <&phy24>;
			phy-mode = "sgmii";
			managed = "in-band-status";
		};

		port@25 {
			reg = <25>;
			label = "lan6";
			pcs-handle = <&serdes7 0>;
			phy-handle = <&phy25>;
			phy-mode = "sgmii";
			managed = "in-band-status";
		};

		port@26 {
			reg = <26>;
			label = "lan7";
			pcs-handle = <&serdes8 0>;
			phy-handle = <&phy26>;
			phy-mode = "sgmii";
			managed = "in-band-status";
		};

		port@27 {
			reg = <27>;
			label = "lan8";
			pcs-handle = <&serdes9 0>;
			phy-handle = <&phy27>;
			phy-mode = "sgmii";
			managed = "in-band-status";
		};

		/* Internal SoC/CPU port */
		port@28 {
			ethernet = <&ethernet0>;
			reg = <28>;
			phy-mode = "internal";

			fixed-link {
				speed = <1000>;
				full-duplex;
			};
		};
	};
};
